Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-12-14T14:15:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 14 14:15:46 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{1504D79B-7F4F-491C-BC5E-9DC4A3E48B52}\ifc * Database version: 5507 * Database creation date: Tue Dec 14 14:15:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 14 14:15:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 14 14:15:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 13484721_AS1_11978160_B4847, 11978160_AS1_B4847:13484721_AS1_11978160_B4847:207005
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Connection_Dampf, z_Miele_Design_BRWS, z_Miele_Design_CLST, z_Miele_Design_Cast, SAN Plastic, z_Miele_Design_Alusilver, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 13484721_AS1_11978160_B4847
